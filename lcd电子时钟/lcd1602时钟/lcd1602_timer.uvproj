# Keil uVision project lcd1602_timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lcd1602_timer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\users\inc
  group main
    ./: STARTUP.A51 main.c
  group users
    ./users/src/: dht11.c ds1302.c key.c other.c lcd1602.c
